DESCRIPTION = "OMAP3 PWM driver"
PR = "r1"

inherit module

S = "${OEBASE}/xFP/omap3-pwm"
